## zephyr/Kconfig
```kconfig
menu "app_nvs_lib options"

config APP_NVS_LIB
    bool "Enable app_nvs_lib Library"
    default y
    help
      Enable support for app_nvs_lib.


endmenu
```
